<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>AptRx</value></param>
<param><key>author</key><value>Departamento de Telecomunicaciones - iie - Fing- UdelaR</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Receptor APT NOAA</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Receptor APT NOAA</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>af_gain</value></param>
<param><key>value</key><value>1.</value></param>
<param><key>gui_hint</key><value>2,4,1,1</value></param>
<param><key>label</key><value>Volumen audio</value></param>
<param><key>min_len</key><value>100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>.1</value></param>
<param><key>stop</key><value>3</value></param>
<param><key>widget</key><value>dial</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>bpf_hp</value></param>
<param><key>value</key><value>5000</value></param>
<param><key>gui_hint</key><value>tab@2</value></param>
<param><key>label</key><value>Band Pass Filter Hp</value></param>
<param><key>min_len</key><value>100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>800</value></param>
<param><key>step</key><value>10</value></param>
<param><key>stop</key><value>8000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>bpf_lp</value></param>
<param><key>value</key><value>500</value></param>
<param><key>gui_hint</key><value>tab@2</value></param>
<param><key>label</key><value>Band Pass Filter Lp</value></param>
<param><key>min_len</key><value>100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>200</value></param>
<param><key>step</key><value>10</value></param>
<param><key>stop</key><value>500</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>cutoff</value></param>
<param><key>value</key><value>40</value></param>
<param><key>gui_hint</key><value>2,1,1,1</value></param>
<param><key>label</key><value>Frecuencia de corte LPF (kHz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>10</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>48</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>fcd_freq</value></param>
<param><key>value</key><value>137100000</value></param>
<param><key>gui_hint</key><value>1,1, 1,2</value></param>
<param><key>label0</key><value>NOAA 15</value></param>
<param><key>label1</key><value>NOAA 18</value></param>
<param><key>label2</key><value>NOAA 19</value></param>
<param><key>label3</key><value>Oceano FM</value></param>
<param><key>label</key><value>Seleccionar Satelite</value></param>
<param><key>num_opts</key><value>4</value></param>
<param><key>option0</key><value>137620000</value></param>
<param><key>option1</key><value>137912500</value></param>
<param><key>option2</key><value>137100000</value></param>
<param><key>option3</key><value>93900000</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>lna_gain_0</value></param>
<param><key>value</key><value>30</value></param>
<param><key>gui_hint</key><value>1,4,1,1</value></param>
<param><key>label0</key><value>0 dB</value></param>
<param><key>label1</key><value>+ 10 dB</value></param>
<param><key>label2</key><value>+ 20 dB</value></param>
<param><key>label3</key><value>+ 30 dB</value></param>
<param><key>label4</key><value>+ 35 dB</value></param>
<param><key>label</key><value>Ganancia SDR (dB)</value></param>
<param><key>num_opts</key><value>5</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>10</value></param>
<param><key>option2</key><value>20</value></param>
<param><key>option3</key><value>30</value></param>
<param><key>option4</key><value>35</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>prefix</value></param>
<param><key>value</key><value>"/home/tallerine/sdr-apt/wav/"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>recfile</value></param>
<param><key>value</key><value>prefix +"fm_demod/"+ datetime.now().strftime("%Y.%m.%d.%H.%M.%S") + ".wav"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>recfile2</value></param>
<param><key>value</key><value>prefix +"am_demod/"+ datetime.now().strftime("%Y.%m.%d.%H.%M.%S") + ".wav"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>960000</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0</value></param>
<param><key>value</key><value>fcd_freq</value></param>
<param><key>gui_hint</key><value>1,3,1,1</value></param>
<param><key>label</key><value>Frecuencia Portadora</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>analog_wfm_rcv</key>
<param><key>id</key><value>analog_wfm_rcv_0_0</value></param>
<param><key>audio_decimation</key><value>2</value></param>
<param><key>comment</key><value>Demodulación FM</value></param>
<param><key>quad_rate</key><value>96000</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0</value></param>
<param><key>type</key><value>interp_fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>bpf_hp</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>low_cutoff_freq</key><value>bpf_lp</value></param>
<param><key>samp_rate</key><value>48000</value></param>
<param><key>width</key><value>200</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_0</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0_0</value></param>
<param><key>n</key><value>5</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0_0</value></param>
<param><key>length</key><value>11</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1/11.</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>af_gain</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0_0</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
<param><key>comment</key><value>Registro de archivo de audio</value></param>
<param><key>file</key><value>recfile</value></param>
<param><key>samp_rate</key><value>20800</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_1_0</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
<param><key>file</key><value>recfile2</value></param>
<param><key>samp_rate</key><value>4160</value></param>
</block>
<block>
<key>hilbert_fc</key>
<param><key>id</key><value>hilbert_fc_0_0</value></param>
<param><key>num_taps</key><value>5</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from datetime import datetime</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0</value></param>
<param><key>cutoff_freq</key><value>2000</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>10</value></param>
<param><key>samp_rate</key><value>20800</value></param>
<param><key>width</key><value>500</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_1_0</value></param>
<param><key>cutoff_freq</key><value>cutoff*1000</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>30</value></param>
<param><key>samp_rate</key><value>96000</value></param>
<param><key>width</key><value>500</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>fcd_freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>lna_gain_0</value></param>
<param><key>comment</key><value>Bloque SDR</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>bw</key><value>96000</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0_0</value></param>
<param><key>bw</key><value>48000</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_1_0</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>48000</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>tab@2</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>alpha1</key><value>1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>2080</value></param>
<param><key>srate</key><value>2080*2</value></param>
<param><key>tr_level</key><value>0.4</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>.5</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2_0</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>96000</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymax</key><value>5</value></param>
<param><key>ymin</key><value>-5</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_0</value></param>
<param><key>bw</key><value>96000</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>comment</key><value>Bajo tasa de muestreo</value></param>
<param><key>decim</key><value>samp_rate</value></param>
<param><key>interp</key><value>96000</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0_0</value></param>
<param><key>comment</key><value>Cambio tasa de muestreo</value></param>
<param><key>decim</key><value>48000</value></param>
<param><key>interp</key><value>20800</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab</value></param>
<param><key>label0</key><value>Senal en recepcion</value></param>
<param><key>label1</key><value>Demodulacion FM</value></param>
<param><key>label2</key><value>Demodulacion AM</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<connection><source_block_id>analog_wfm_rcv_0_0</source_block_id><sink_block_id>audio_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_wfm_rcv_0_0</source_block_id><sink_block_id>band_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>blocks_wavfile_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>hilbert_fc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_0</source_block_id><sink_block_id>blocks_moving_average_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_0</source_block_id><sink_block_id>blocks_wavfile_sink_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hilbert_fc_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1_0</source_block_id><sink_block_id>analog_wfm_rcv_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1_0</source_block_id><sink_block_id>qtgui_time_sink_x_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>low_pass_filter_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0_0</source_block_id><sink_block_id>low_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
